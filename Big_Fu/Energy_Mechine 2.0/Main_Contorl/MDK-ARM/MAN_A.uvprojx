# Keil uVision project MAN_A.uvprojx, settings and files
target MAN_A (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: MAN_A +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Core/Inc;../Hardware;../dm4340;../MY_Task;"F:/CubeMax软件/FirmwarePackage/STM32Cube_FW_F4_V1.28.3/Drivers/STM32F4xx_HAL_Driver/Inc";"F:/CubeMax软件/FirmwarePackage/STM32Cube_FW_F4_V1.28.3/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy";"F:/CubeMax软件/FirmwarePackage/STM32Cube_FW_F4_V1.28.3/Middlewares/Third_Party/FreeRTOS/Source/include";"F:/CubeMax软件/FirmwarePackage/STM32Cube_FW_F4_V1.28.3/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS";"F:/CubeMax软件/FirmwarePackage/STM32Cube_FW_F4_V1.28.3/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F";"F:/CubeMax软件/FirmwarePackage/STM32Cube_FW_F4_V1.28.3/Drivers/CMSIS/Device/ST/STM32F4xx/Include";"F:/CubeMax软件/FirmwarePackage/STM32Cube_FW_F4_V1.28.3/Drivers/CMSIS/Include"
  asm include: ../Core/Inc;C:/Users/86158/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.3/Drivers/CMSIS/Include;"F:/CubeMax软件/Firmware Package/STM32Cube_FW_F4_V1.28.3/Drivers/CMSIS/Include"
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../MY_Task/: Mpu_Task.c Mpu_Task.h Arm_Final_Task.c Arm_Final_Task.h Data_train.c Data_train.h
    ../Core/Src/: main.c gpio.c freertos.c can.c spi.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Hardware
    ../Hardware/: Mpu6500.c Mpu6500.h struct_typedef.h motor.c motor.h PID.c PID.h
  group dm4340
    ../dm4340/: dm4340_ctrl.c dm4340_ctrl.h dm4340_drv.h dm4340_drv.c can_bsp.c can_bsp.h can_driver.c can_driver.h
  group Drivers/STM32F4xx_HAL_Driver
    F:/CubeMax软件/Firmware Package/STM32Cube_FW_F4_V1.28.3/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Middlewares/FreeRTOS
    F:/CubeMax软件/Firmware Package/STM32Cube_FW_F4_V1.28.3/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    F:/CubeMax软件/Firmware Package/STM32Cube_FW_F4_V1.28.3/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    F:/CubeMax软件/Firmware Package/STM32Cube_FW_F4_V1.28.3/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    F:/CubeMax软件/Firmware Package/STM32Cube_FW_F4_V1.28.3/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0
